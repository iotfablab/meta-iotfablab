FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += " \
	file://0001-Add-UDP-Ports-for-Apps-in-Config-File.patch \
	"
