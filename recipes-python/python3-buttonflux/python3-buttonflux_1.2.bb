inherit setuptools3 pypi
require python3-buttonflux.inc
