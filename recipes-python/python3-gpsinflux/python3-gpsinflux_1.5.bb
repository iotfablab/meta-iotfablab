inherit setuptools3 pypi
include python3-gpsinflux.inc
