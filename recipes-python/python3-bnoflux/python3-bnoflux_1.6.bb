inherit setuptools3 pypi
include python3-bnoflux.inc
