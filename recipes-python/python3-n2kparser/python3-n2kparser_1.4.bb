inherit setuptools3 pypi
include python3-n2kparser.inc
