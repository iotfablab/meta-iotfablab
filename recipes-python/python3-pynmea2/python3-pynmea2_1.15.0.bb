inherit setuptools3 pypi
include python3-pynmea2.inc

